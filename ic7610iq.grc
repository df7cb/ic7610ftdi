options:
  parameters:
    generate_options: qt_gui
    id: ic7610iq
    output_language: python
    title: IC-7610 I/Q Receiver
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '40'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 14020e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain (dB)
    start: '-10'
    step: '.1'
    stop: '10'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(gain/10)
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/decim * 0.44
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 3e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2000'
    server: 'True'
    type: short
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/decim
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    grid: 'True'
    legend: 'False'
    showports: 'True'
    type: complex
    ymax: '20'
    ymin: '-30'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decim
    fc: freq
    fftsize: '1024'
    int_max: '20'
    int_min: '-30'
    name: ''
    type: complex
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [network_tcp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
